Commit message: ur5e_simulator now added

File: ros2_ws/test.urdf (robot description, URDF)
Before this commit: robot ur5e_rgbd, 17 links, 16 joints
Joints:
- joint realsense_mount_joint: origin xyz=0 0 0.08 rpy=0 0 0 -> xyz=0.08 0.0 -0.02 rpy=0 -1.86 0
